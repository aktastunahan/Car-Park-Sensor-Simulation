# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: TM4C1230H6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: ADC_ROUTINES.s CONVRT.s DELAYS.s INIT_MEM.s main.s MOTOR_ROUTINES.s OutStr.s SPI_ROUTINES.s ST_CTRL.s Startup.s HCSR04_ROUTINES.s InitSysTick.s
